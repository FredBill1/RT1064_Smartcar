# Keil uVision project RT106X.uvprojx, settings and files
target nor_sdram_zf_dtcm_v5 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.13.1.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RT106X
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1064DVL6A,SKIP_SYSCLK_INIT,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_DCD_ENABLE =1, XIP_BOOT_HEADER_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0,USB_STACK_BM,
  c misc: --library_interface=armcc --diag_suppress=66,1296,186,1 --bss_threshold=0
  c include: ..\CODE;..\USER\inc;..\USER\src;..\..\Libraries\seekfree_libraries;..\..\Libraries\nxp_libraries\CMSIS\Include;..\..\Libraries\nxp_libraries\cmsis_drivers;..\..\Libraries\nxp_libraries\drives;..\..\Libraries\nxp_libraries\startup;..\..\Libraries\nxp_libraries\startup\MDK-ARM;..\..\Libraries\nxp_libraries\utilities;..\..\Libraries\nxp_libraries\utilities\debug_console;..\..\Libraries\nxp_libraries\utilities\str;..\..\Libraries\nxp_libraries\xip;..\..\Libraries\nxp_libraries\deceive;..\..\Libraries\nxp_libraries\components\serial_manager;..\..\Libraries\nxp_libraries\components\uart;..\..\Libraries\nxp_libraries\components\lists;..\..\Libraries\nxp_libraries\components\osa;..\..\Libraries\nxp_libraries\components\serial_manager\usb_cdc_adapter;..\..\Libraries\nxp_libraries\middleware\usb\include;..\..\Libraries\nxp_libraries\middleware\usb\phy;..\..\Libraries\nxp_libraries\middleware\usb\device;..\..\Libraries\nxp_libraries\middleware\sdmmc\inc;..\..\Libraries\nxp_libraries\middleware\sdmmc\port;..\..\Libraries\nxp_libraries\middleware\sdmmc\port\usdhc;..\..\Libraries\nxp_libraries\middleware\sdmmc\port\usdhc\interrupt;..\..\Libraries\nxp_libraries\middleware\sdmmc\src;..\..\Libraries\nxp_libraries\middleware\fatfs\source;..\..\Libraries\nxp_libraries\middleware\fatfs\source\fsl_sd_disk;..\..\Libraries\seekfree_libraries\common;..\..\Libraries\seekfree_libraries\board;..\..\Libraries\seekfree_peripheral
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\scf\MIMXRT1064xxxxx_flexspi_nor_v5.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt)
  group board
    ../../Libraries/seekfree_libraries/board/: board.c board.h clock_config.c pin_mux.c
  group components
    ../../Libraries/nxp_libraries/components/lists/: generic_list.c generic_list.h
    ../../Libraries/nxp_libraries/components/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
    ../../Libraries/nxp_libraries/components/uart/: lpuart_adapter.c uart.h
    ../../Libraries/nxp_libraries/components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group deceive
    ../../Libraries/nxp_libraries/deceive/: system_MIMXRT1064.h system_MIMXRT1064.c MIMXRT1064_features.h MIMXRT1064.h fsl_device_registers.h
  group doc
    ../../Libraries/doc/: read me.txt version.txt
  group drives
    ../../Libraries/nxp_libraries/drives/: fsl_adc.c fsl_adc.h fsl_adc_etc.c fsl_adc_etc.h fsl_aipstz.c fsl_aipstz.h fsl_aoi.c fsl_aoi.h fsl_bee.c fsl_bee.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_csi.c fsl_csi.h fsl_dcdc.c fsl_dcdc.h fsl_dcp.c fsl_dcp.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_elcdif.c fsl_elcdif.h fsl_enc.c fsl_enc.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flexcan.c fsl_flexcan.h fsl_flexio.c fsl_flexio.h fsl_flexio_camera.c fsl_flexio_camera.h fsl_flexio_i2c_master.c fsl_flexio_i2c_master.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio_i2s_edma.c fsl_flexio_i2s_edma.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_flexio_uart.c fsl_flexio_uart.h fsl_flexio_uart_edma.c fsl_flexio_uart_edma.h fsl_flexram.c fsl_flexram.h fsl_flexspi.c fsl_flexspi.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_kpp.c fsl_kpp.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_pit.c fsl_pit.h fsl_pmu.c fsl_pmu.h fsl_pwm.c fsl_pwm.h fsl_pxp.c fsl_pxp.h fsl_qtmr.c fsl_qtmr.h fsl_rtwdog.c fsl_rtwdog.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_semc.c fsl_semc.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_snvs_lp.c fsl_snvs_lp.h fsl_spdif.c fsl_spdif.h fsl_spdif_edma.c fsl_spdif_edma.h fsl_src.c fsl_src.h fsl_tempmon.c fsl_tempmon.h fsl_trng.c fsl_trng.h fsl_tsc.c fsl_tsc.h fsl_usdhc.c fsl_usdhc.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h fsl_ocotp.c fsl_ocotp.h
  group fatfs
    ../../Libraries/nxp_libraries/middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
    ../../Libraries/nxp_libraries/middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group sdmmc
    ../../Libraries/nxp_libraries/middleware/sdmmc/inc/: fsl_mmc.h fsl_sd.h fsl_sdio.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
    ../../Libraries/nxp_libraries/middleware/sdmmc/port/: fsl_sdmmc_event.h
    ../../Libraries/nxp_libraries/middleware/sdmmc/port/usdhc/interrupt/: fsl_sdmmc_event.c fsl_sdmmc_host.c
    ../../Libraries/nxp_libraries/middleware/sdmmc/src/: fsl_mmc.c fsl_sd.c fsl_sdio.c fsl_sdmmc_common.c
  group seekfree_libraries
    ../../Libraries/seekfree_libraries/: zf_adc.c zf_adc.h zf_camera.c zf_camera.h zf_csi.c zf_csi.h zf_flash.c zf_flash.h zf_gpio.c zf_gpio.h zf_iic.c zf_iic.h zf_iomuxc.c zf_iomuxc.h zf_pit.c zf_pit.h zf_pwm.c zf_pwm.h zf_qtimer.c zf_qtimer.h zf_rom_api.c zf_rom_api.h zf_spi.c zf_spi.h zf_systick.c zf_systick.h zf_uart.c zf_uart.h zf_vector.c zf_vector.h zf_usb_cdc.c zf_usb_cdc.h zf_sdcard.c zf_sdcard.h
    ../../Libraries/seekfree_libraries/common/: common.c common.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h
  group seekfree_peripheral
    ../../Libraries/seekfree_peripheral/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h SEEKFREE_W25QXXJV.c SEEKFREE_W25QXXJV.h SEEKFREE_MT9V03X.c SEEKFREE_MT9V03X.h SEEKFREE_MT9V03X_CSI.c SEEKFREE_MT9V03X_CSI.h SEEKFREE_SCC8660.c SEEKFREE_SCC8660.h SEEKFREE_SCC8660_CSI.c SEEKFREE_SCC8660_CSI.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_IPS200_PARALLEL8.c SEEKFREE_IPS200_PARALLEL8.h
  group startup
    ../../Libraries/nxp_libraries/startup/MDK-ARM/: startup_MIMXRT1064.s
  group usb
    ../../Libraries/nxp_libraries/middleware/usb/device/: usb_device_ehci.c usb_device_ehci.h usb_device_dci.c usb_device_dci.h usb_device.h
    ../../Libraries/nxp_libraries/middleware/usb/include/: usb.h usb_misc.h usb_spec.h
    ../../Libraries/nxp_libraries/middleware/usb/phy/: usb_phy.c usb_phy.h
    ../../Libraries/nxp_libraries/components/serial_manager/usb_cdc_adapter/: usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_class.c usb_device_class.h usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h
  group user_c
    ../USER/src/: main.cpp isr.cpp devices.cpp
  group user_h
    ../USER/inc/: isr.h RT106X_config.h PinConfig.h devices.hpp
    ../../Libraries/seekfree_libraries/: headfile.h
    ../../Libraries/rttherad_libraries/bsp/: rtconfig.h
  group utilities
    ../../Libraries/nxp_libraries/utilities/: fsl_assert.c
    ../../Libraries/nxp_libraries/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../Libraries/nxp_libraries/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../Libraries/nxp_libraries/xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
  group rtthread_src
    ../../Libraries/rttherad_libraries/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group rtthread_inc
    ../../Libraries/rttherad_libraries/include/: rtdbg.h rtdebug.h rtdef.h rthw.h rtlibc.h rtm.h rtservice.h rtthread.h
    ../../Libraries/rttherad_libraries/include/libc/: libc_dirent.h libc_errno.h libc_fcntl.h libc_fdset.h libc_ioctl.h libc_limits.h libc_signal.h libc_stat.h libc_stdio.h
  group rtthread_lib
    ../../Libraries/rttherad_libraries/libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group rtthread_components
    ../../Libraries/rttherad_libraries/components/finsh/: cmd.c finsh.h finsh_api.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h msh.c msh.h msh_file.c shell.c shell.h symbol.c
  group rtthread_cplusplus
    ../../Libraries/rttherad_libraries/components/cplusplus/: crt.h crt_init.c cxx_crt.cpp cxx_Mutex.cpp cxx_Semaphore.cpp cxx_Thread.cpp Lock.h Mail.h Mutex.h Queue.h Semaphore.h Thread.h
  group user_components
    ../CODE/components/: SerialIO.cpp SerialIO.hpp
  group rtthread_libc
    ../../Libraries/rttherad_libraries/components/libc/compilers/armlibc/: dirent.h fcntl.h libc.c libc.h libc_syms.c mem_std.c stdio.c stubs.c unistd.h
    ../../Libraries/rttherad_libraries/components/libc/compilers/armlibc/sys/: errno.h ioctl.h mman.h stat.h types.h unistd.h
  group user_driver
    ../CODE/driver/: Encoder.hpp ICM20948.hpp ICM20948.cpp IPS.cpp IPS.hpp MotorDRV.hpp
    ../CODE/driver/src/: Systick.cpp
  group eMD-SmartMotion-ICM20948-1.1.0-MP
    ../../Libraries/eMD-SmartMotion-ICM20948-1.1.0-MP/Invn/Devices/Drivers/ICM20948/: Icm20948Augmented.c Icm20948AuxCompassAkm.c Icm20948AuxTransport.c Icm20948DataBaseControl.c Icm20948DataBaseDriver.c Icm20948DataConverter.c Icm20948Dmp3Driver.c Icm20948LoadFirmware.c Icm20948MPUFifoControl.c Icm20948SelfTest.c Icm20948Setup.c Icm20948Transport.c
    ../../Libraries/eMD-SmartMotion-ICM20948-1.1.0-MP/Invn/Devices/Drivers/Ak0991x/: Ak0991x.c
    ../../Libraries/eMD-SmartMotion-ICM20948-1.1.0-MP/Invn/Devices/: Sensor.c
  group user_ICM20948
    ../CODE/driver/ICM20948/: dmp_img.cpp system.cpp
  group rosRT
    ../CODE/components/rosRT/src/: Topic.cpp
  group pose_kailman
    ../CODE/components/pose_kalman/src/: pose_kalman_test.cpp
  group user_nodes
    ../CODE/nodes/: wireless.cpp apriltagDetect.cpp imgUSBXfer.cpp imuEcho.cpp testMotor.cpp testQTimer.cpp motorControl.cpp testMotorPwm.cpp uartMasterTest.cpp uartSlaveTest.cpp testKey.cpp
  group imgProc
    ../CODE/components/imgProc/src/apriltag/internal/: StaticBuffer.cpp threshold.cpp segmentation.cpp Hashmap.cpp fit_quad.cpp Graymodel.cpp decode_quad.cpp Quick_decode.cpp reconcile_detections.cpp homography.cpp globalVariables.cpp
    ../CODE/components/imgProc/src/apriltag/: visualization.cpp tag25h9.cpp apriltag.cpp apriltag_pose.cpp fmath.cpp visualization_pose.cpp
    ../CODE/components/imgProc/src/apriltag/undisort/: undisort.cpp
  group arm_math
    ../../Libraries/nxp_libraries/CMSIS/math/BasicMathFunctions/: arm_abs_f32.c
    ../../Libraries/nxp_libraries/CMSIS/math/CommonTables/: arm_common_tables.c
    ../../Libraries/nxp_libraries/CMSIS/math/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
  group user_utils
    ../CODE/utils/src/: FuncThread.cpp RDeque.cpp PeekQueue.cpp
  group controller
    ../CODE/components/controller/src/controller/: LADRC.cpp
target nor_sdram_zf_dtcm_v6 (6160000::V6.16::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.13.1.1
  cpu: as above
  output: RT106X
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=9 wLevel=3
  c define: __FPU_PRESENT,ARM_MATH_CM7,CPU_MIMXRT1064DVL6A,SKIP_SYSCLK_INIT,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_DCD_ENABLE =1, XIP_BOOT_HEADER_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0,USB_STACK_BM,EIGEN_NO_IO,EIGEN_NO_DEBUG,NDEBUG
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb -fno-exceptions
  c include: ..\CODE;..\USER\inc;..\USER\src;..\..\Libraries\seekfree_libraries;..\..\Libraries\nxp_libraries\CMSIS\Include;..\..\Libraries\nxp_libraries\cmsis_drivers;..\..\Libraries\nxp_libraries\drives;..\..\Libraries\nxp_libraries\startup;..\..\Libraries\nxp_libraries\startup\MDK-ARM;..\..\Libraries\nxp_libraries\utilities;..\..\Libraries\nxp_libraries\utilities\debug_console;..\..\Libraries\nxp_libraries\utilities\str;..\..\Libraries\nxp_libraries\xip;..\..\Libraries\nxp_libraries\deceive;..\..\Libraries\nxp_libraries\components\serial_manager;..\..\Libraries\nxp_libraries\components\uart;..\..\Libraries\nxp_libraries\components\lists;..\..\Libraries\nxp_libraries\components\osa;..\..\Libraries\nxp_libraries\components\serial_manager\usb_cdc_adapter;..\..\Libraries\nxp_libraries\middleware\usb\include;..\..\Libraries\nxp_libraries\middleware\usb\phy;..\..\Libraries\nxp_libraries\middleware\usb\device;..\..\Libraries\nxp_libraries\middleware\sdmmc\inc;..\..\Libraries\nxp_libraries\middleware\sdmmc\port;..\..\Libraries\nxp_libraries\middleware\sdmmc\port\usdhc;..\..\Libraries\nxp_libraries\middleware\sdmmc\port\usdhc\interrupt;..\..\Libraries\nxp_libraries\middleware\sdmmc\src;..\..\Libraries\nxp_libraries\middleware\fatfs\source;..\..\Libraries\nxp_libraries\middleware\fatfs\source\fsl_sd_disk;..\..\Libraries\seekfree_libraries\common;..\..\Libraries\seekfree_libraries\board;..\..\Libraries\seekfree_peripheral;..\..\Libraries\rttherad_libraries\bsp;..\..\Libraries\rttherad_libraries\components\finsh;..\..\Libraries\rttherad_libraries\include;..\..\Libraries\rttherad_libraries\include\libc;..\..\Libraries\rttherad_libraries\components\cplusplus;..\CODE\components;..\..\Libraries\eigen;..\CODE\driver;..\..\Libraries\eMD-SmartMotion-ICM20948-1.1.0-MP;..\..\Libraries\kalman\include;..\CODE\components\imgProc\inc;..\CODE\components\controller\inc;..\CODE\components\pose_kalman\inc
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  asm include: ..\..\Libraries\rttherad_libraries\libcpu\arm\cortex-m7
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\scf\MIMXRT1064xxxxx_flexspi_nor.scf
